# Keil uVision project garage_system.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: garage_system
  c flags: Optim=1
  c include: ..\..\2-Drivers\1-GPIO_Driver;..\..\2-Drivers\2-common_Drivers;..\..\2-Drivers\3-Systick_Timer;..\..\2-Drivers\4-LCD_Driver;..\..\2-Drivers\6-Timer_Driver;..\..\2-Drivers\8-PWM_Generator
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group APP
    ./: startup_TM4C123.s main.c
    ../../4-System_file/: system_TM4C123.c
  group Drivers
    ../../2-Drivers/1-GPIO_Driver/: gpio.c
    ../../2-Drivers/3-Systick_Timer/: systick_timer.c
    ../../2-Drivers/4-LCD_Driver/: LCD.c
    ../../2-Drivers/6-Timer_Driver/: timer.c
    ../../2-Drivers/8-PWM_Generator/: pwm.c
